# IAR project Lora_FW.ewp, settings and files
configuration Lora_FW (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\Tasks\ctrl_Task; ..\Tasks\lora_Task; ..\Libs\Device_ctrl; ..\Tasks\script_Task; ..\Tasks\script_Task\board; ..\Tasks\script_Task\pymite\src\vm; ..\Tasks\script_Task\conversion\inc; ..\Libs\EXT_Flash
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Lora_FW.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: freertos.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_usb.c
  group Libs/Device_ctrl
    ../Libs/Device_ctrl/: Device_ctrl.c Device_ctrl.h
  group Libs/Flash
    ../Libs/EXT_Flash/: EXT_Flash.c EXT_Flash.h
  group Libs/PyMite/board
    ../Tasks/script_Task/board/: py_plat.c py_plat.h py_pmfeatures.h
  group Libs/PyMite/vm
    ../Tasks/script_Task/pymite/src/vm/: py_bytearray.c py_bytearray.h py_class.c py_class.h py_codeobj.c py_codeobj.h py_dict.c py_dict.h py_float.c py_float.h py_frame.c py_frame.h py_func.c py_func.h py_global.c py_global.h py_heap.c py_heap.h py_img.c py_img.h py_int.c py_int.h py_interp.c py_interp.h py_list.c py_list.h py_mem.c py_mem.h py_module.c py_module.h py_obj.c py_obj.h py_plat_interface.h py_pm.c py_pm.h py_pmEmptyPlatformDefs.h py_pmFeatureDependencies.h py_seglist.c py_seglist.h py_seq.c py_seq.h py_sli.c py_sli.h py_strobj.c py_strobj.h py_thread.c py_thread.h py_tuple.c py_tuple.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Tasks/ctrl_Task
    ../Tasks/ctrl_Task/: ctrl_Task.c ctrl_Task.h
  group Tasks/lora_Task
    ../Tasks/lora_Task/: lora_Task.c lora_Task.h
  group Tasks/script_Task
    ../Tasks/script_Task/: script_Task.c script_Task.h
  group Tasks/script_Task/scripts/std
    ../Tasks/script_Task/conversion/inc/: py_std.h py_std_native.c
  group Tasks/script_Task/scripts/usr
    ../Tasks/script_Task/conversion/inc/: py_usr.h py_usr_native.c
